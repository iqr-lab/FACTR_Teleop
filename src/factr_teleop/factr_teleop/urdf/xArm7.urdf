Commit message: 

File: src/factr_teleop/factr_teleop/urdf/xArm7.urdf (robot description, URDF)
Before this commit: robot xArm7, 8 links, 7 joints
Joints:
- joint joint4: origin xyz=-0.03525 -0.018 0.04325 rpy=-1.5708 0 1.5708 -> xyz=-0.03525 -0.018 0.04325 rpy=-1.5708 3.141 1.5708
